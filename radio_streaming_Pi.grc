options:
  parameters:
    generate_options: no_gui
    id: radio_streaming_Pi
    output_language: python
    run_options: run
    thread_safe_setters: '1'
    title: radio_streaming_Pi
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: station
  id: variable
  parameters:
    value: 96.9e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 192e3
  states: {}
- name: epy_module_server
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      import socket
      # import string

      def server(tt):
      	while True:
      		# Configure socket
      		sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)
      		sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
      		sock.bind(('192.168.137.8',4242))
      		# Listen
      		print("Waiting for connection...")
      		sock.listen(1)
      		# Connected
      		conn,addr=sock.accept()
      		with conn:
      			print('Connected from ', addr)
      			message = "" # Variable to store complete message
      			while True:
      				# Get text
      				data=conn.recv(1)
      				if data:
      					data=data.decode()
      					message = message+data
      					print(message) 
      					if '>' in message: # Delimeter to indicate end of message
      						try:
      							input_station = message.replace('>','')
      							print('Current station: ' + str(tt.get_station()))
      							tt.station = input_station
      							tt.set_station(float(input_station)*1000000)
      							print('New station: ' + str(tt.get_station()))
      							message = "" # Reset variable
      						except:
      							message = "" # Reset variable
      							print("Error: variable not set")						
      					# Quit
      					if 'q' in data:
      						print("Closing connection...")
      						sock.shutdown(socket.SHUT_RDWR)
      						sock.close()
      						break # Back to listen loop
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 96e3
    decim: '6'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 48e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: station
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server")
      #import threading
      threading.Thread(target=epy_module_server.server,args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
