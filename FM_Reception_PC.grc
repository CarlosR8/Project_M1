options:
  parameters:
    author: cmrivera
    generate_options: qt_gui
    id: FM_Reception_PC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: station
  id: variable
  parameters:
    value: 096.9e6
  states: {}
- name: stream_variable
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: epy_module_GUI
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      import tkinter as tk
      import tkinter.font as tkFont

      def gui(tt):
          while True:
              window = tk.Tk()
              label = tk.Label(text="Current station: ")
              label.grid(column=0, row=0, columnspan=2)

              station_number = tk.StringVar()
              
              # Entry_Control = tk.Entry(window, textvariable=station_number, validate="key", validatecommand=callback, justify='center')
              Entry_Control = tk.Entry(window, textvariable=station_number, justify='center')
              Entry_Control.grid(column=0, row=1, columnspan=2)

              button = tk.Button(text="Change", command= lambda: changeStation(tt,Entry_Control.get()))
              button.grid(column=0, row=2)
              close = tk.Button(text="Close", command= lambda: closeButton(window))
              close.grid(column=1, row=2)

              window.mainloop()

      def callback():
          # print(station_number.get()) #Triggered by typing
          return True

      def changeStation(tt, station):
          try:
              tt.stream_variable = "True"
              # tt.set_stream_variable(tt.stream_variable)
              tt.set_stream_variable("True")
              tt.station = station
              tt.set_station(tt.station)
              print(tt.get_station())
              # host = '192.168.137.8'
              # port = 4242  # socket server port number

              # client_socket = socket.socket()  # instantiate
              # client_socket.connect((host, port))  # connect to the server

              # message = input(" -> ")  # take input

              # while message.lower().strip() != 'bye':
              #     client_socket.send(message.encode())  # send message
              #     data = client_socket.recv(1024).decode()  # receive response

              #     print('Received from server: ' + data)  # show in terminal

              #     message = input(" -> ")  # again take input

              # client_socket.close()  # close the connection
          except:
              print("Error!")

      def closeButton(window):
          window.quit()
  states: {}
- name: epy_module_client
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      import socket

      def client(tt):
          while True:
              # Storage variables initial values
              test_variable = "False"
              # Try to connect
              host = '192.168.137.8'
              port = 4242
              client_socket = socket.socket()
              client_socket.connect((host, port))
              if(client_socket.getsockname()[0] != "0.0.0.0"):
                  # Connected
                  print("Connected to server")
                  while True:
                          # Check if variables have change
                          # print(tt.get_stream_variable())
                          # if(tt.get_stream_variable() != test_variable):
                          if(tt.get_stream_variable() == "True"):
                              tt.set_stream_variable("False")
                              # print(tt.get_stream_variable())
                              print("sending message")
                              # test_variable = tt.get_stream_variable() # Store current value
                              # message_ = "test!"
                              client_socket.send(tt.get_station().encode())
                              # client_socket.close()



      # def client(tt):
      #     while True:
      #         # with socket.socket(socket.AF_INET, socket.SOCK_STREAM) as s:
      #         #     print(testing)
      #         #     s.connect(('192.168.137.8', 4242))
      #         #     if(testing != ""):
      #         #         print(testing)
                      
      #         #         # s.sendall(b'Hello, world')
      #         #         # s.sendall(b'{}'.format(station + ">"))
      #         #         s.send(testing.encode())
      #         #         data = s.recv(1024)

      #         #         print('Received', repr(data))
      #         #         print(testing)
      #         #         testing=""
      #         host = '192.168.137.8'
      #         port = 4242  # socket server port number

      #         client_socket = socket.socket()  # instantiate
      #         print(client_socket.getpeername())
      #         client_socket.connect((host, port))  # connect to the server
      #         # if(client_socket.raddr):
      #             # print("conncted")
      #         print(client_socket.getpeername())

      #         message = "test..."  # take input
      #         # print(tt.get_stream_variable())
      #         # while tt.get_stream_variable() == 'True':
      #             # print("sending message")
      #         client_socket.send(message.encode())  # send message
              
      #         data = client_socket.recv(1024).decode()  # receive response
              
      #             # print('Received from server: ' + data)  # show in terminal

      #             # message = input(" -> ")  # again take input

      #         # client_socket.close()  # close the connection
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting client and GUI")
      import threading
      threading.Thread(target=epy_module_client.client, daemon=True, args=(self,)).start()
      threading.Thread(target=epy_module_GUI.gui, daemon=True, args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', audio_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
