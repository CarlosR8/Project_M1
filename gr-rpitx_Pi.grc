options:
  parameters:
    author: cmrivera
    generate_options: no_gui
    id: gr_rpitx_Pi
    output_language: python
    title: gr-rpitx_Pi
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '400e-3'
    freq: 5e3
    offset: '500e-3'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: rpitx_rpitx_sink_0
  id: rpitx_rpitx_sink
  parameters:
    carrier_freq: 86.6e6
    samp_rate: samp_rate
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_magphase_to_complex_0, '0', rpitx_rpitx_sink_0, '0']

metadata:
  file_format: 1
