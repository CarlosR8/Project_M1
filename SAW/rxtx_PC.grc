options:
  parameters:
    author: cmrivera
    generate_options: qt_gui
    id: rxtx_PC
    output_language: python
    title: GNU Spectrum Analyzer by Carlos RIVERA
  states: {}

blocks:
- name: amplitude_
  id: variable_qtgui_entry
  parameters:
    comment: 5,0,1,2
    gui_hint: 5,0,1,2
    label: 'Amplitude                   '
    type: real
    value: '300e-3'
  states: {}
- name: btn_new
  id: variable_qtgui_push_button
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label: New
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: btn_open
  id: variable_qtgui_push_button
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label: Open
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: btn_save
  id: variable_qtgui_push_button
  parameters:
    comment: 0,3,1,1
    gui_hint: 0,3,1,1
    label: Save
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: carrying_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 6,0,1,2
    gui_hint: 6,0,1,2
    label: 'Carrying frequency     '
    type: real
    value: 86.8e6
  states: {}
- name: entry_bandwidth
  id: variable_qtgui_entry
  parameters:
    comment: 3,2,1,2
    gui_hint: 3,2,1,2
    label: 'Bandwidth   '
    type: real
    value: 48e3
  states: {state: disabled}
- name: entry_center_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 3,0,1,2
    gui_hint: 3,0,1,2
    label: 'Center frequency '
    type: real
    value: 86.6e6
  states: {state: disabled}
- name: frequency_
  id: variable_qtgui_entry
  parameters:
    comment: 4,0,1,2
    gui_hint: 4,0,1,2
    label: 'Test frequency           '
    type: real
    value: 86.8e6
  states: {}
- name: label_conf
  id: variable_qtgui_label
  parameters:
    comment: 0,0,1,1
    gui_hint: 0,0,1,1
    label: Configuration
    type: string
    value: ''
  states: {state: disabled}
- name: measured_frequency
  id: variable_qtgui_range
  parameters:
    comment: 2,0,1,4
    gui_hint: 2,0,1,4
    orient: Qt.Horizontal
    start: 80e6
    step: 8.68e6
    stop: 440e6
    value: 86.8e6
    widget: slider
  states: {state: disabled}
- name: measured_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    label: 'Measured Frequency  '
    type: real
    value: 434e6
  states: {}
- name: offset_
  id: variable_qtgui_entry
  parameters:
    comment: 5,2,1,2
    gui_hint: 5,2,1,2
    label: 'Offset          '
    type: real
    value: '0'
  states: {}
- name: sample_rate
  id: variable_qtgui_entry
  parameters:
    comment: 7,2,1,2
    gui_hint: 7,2,1,2
    label: 'Sample rate '
    type: real
    value: 1.152e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 48e3
  states: {state: disabled}
- name: waveform_
  id: variable_qtgui_chooser
  parameters:
    comment: 4,2,1,2
    gui_hint: 4,2,1,2
    label: 'Waveform   '
    labels: '["Constant","Sine","Cosine","Square","Triangle","Saw Tooth"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5]'
    type: int
    value: '3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: epy_module_client
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import socket

      def client(tt):
          while True:
              # Storage variables initial values
              variables=["frequency_","waveform_","amplitude_","offset_","sample_rate","carrying_frequency","measured_frequency"]
              old_values=[]
              new_values=[]
              for variable in variables:
                  exec("old_values.append(tt.get_{}())".format(variable))
              
              new_values = old_values
              # Try to connect
              host = '192.168.137.8'
              port = 4242
              client_socket = socket.socket()
              client_socket.connect((host, port))
              if(client_socket.getsockname()[0] != "0.0.0.0"):
                  # Connected
                  print("Connected to server")
                  while True:
                      # Check if variables have changed
                      for i, variable in enumerate(variables):
                          if(eval("tt.get_{}()".format(variable))!=old_values[i]):
                              value=eval("tt.get_{}()".format(variable))
                              if(variable=="waveform_"):
                                  value=value+100

                              message=variable + "=" + str(value) + ">"
                              client_socket.send(message.encode())
                              # Register new variable value
                              old_values[i]=eval("tt.get_{}()".format(variable))

                      # client_socket.close()
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: sample_rate
    fc: measured_frequency
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,4
    tr_level: '-14'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
    ymax: '-5'
    ymin: '-77'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,4
    size: '1024'
    srate: sample_rate
    tr_level: '0.4'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting client and GUI")
      import threading
      threading.Thread(target=epy_module_client.client, daemon=True, args=(self,)).start()
      # threading.Thread(target=epy_module_GUI.gui, daemon=True, args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
