options:
  parameters:
    author: cmrivera
    generate_options: qt_gui
    id: rxtx_PC
    output_language: python
    title: GNU Spectrum Analyzer by Carlos RIVERA
  states: {}

blocks:
- name: btn_start
  id: variable_qtgui_push_button
  parameters:
    comment: tab_widget_0@1:1,3,1,1
    gui_hint: tab_widget_0@1:1,3,1,1
    label: '"Start"'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: entry_end_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,3,1,1
    gui_hint: tab_widget_0@1:1,2,1,1
    label: End frequency
    type: real
    value: 434.55e6
  states: {}
- name: entry_span_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,2,1,1
    gui_hint: tab_widget_0@1:1,1,1,1
    label: Span
    type: real
    value: 1e3
  states: {}
- name: entry_start_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,0,1,1
    gui_hint: tab_widget_0@1:1,0,1,1
    label: Start frequency
    type: real
    value: 433.5e6
  states: {}
- name: entry_var_amplitude_
  id: variable_qtgui_entry
  parameters:
    comment: 5,0,1,2
    gui_hint: 5,0,1,2
    label: 'Amplitude                   '
    type: real
    value: '300e-3'
  states: {}
- name: entry_var_carrying_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 6,0,1,2
    gui_hint: 6,0,1,2
    label: 'Carrying frequency     '
    type: real
    value: 86.8e6
  states: {}
- name: entry_var_frequency_
  id: variable_qtgui_entry
  parameters:
    comment: 4,0,1,2
    gui_hint: 4,0,1,2
    label: 'Test frequency           '
    type: real
    value: 10e3
  states: {}
- name: entry_var_measured_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    label: 'Measured Frequency  '
    type: real
    value: 434e6
  states: {}
- name: entry_var_offset_
  id: variable_qtgui_entry
  parameters:
    comment: 5,2,1,2
    gui_hint: 5,2,1,2
    label: 'Offset                        '
    type: real
    value: '0.5'
  states: {}
- name: entry_var_sample_rate_gr
  id: variable_qtgui_entry
  parameters:
    comment: 6,2,1,2
    gui_hint: 6,2,1,2
    label: 'Sample rate gr-rpitx  '
    type: real
    value: 200e3
  states: {}
- name: entry_var_sample_rate_osmosdr
  id: variable_qtgui_entry
  parameters:
    comment: 7,2,1,2
    gui_hint: 7,2,1,2
    label: Sample rate Osmosdr
    type: real
    value: 1.152e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: sample_rate = sample_rate_osmosdr
    value: entry_var_sample_rate_osmosdr
  states: {}
- name: sweeping
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: var_record
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: var_waveform_
  id: variable_qtgui_chooser
  parameters:
    comment: 4,2,1,2
    gui_hint: 4,2,1,2
    label: 'Waveform                  '
    labels: '["Constant","Sine","Cosine","Square","Triangle","Saw Tooth"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5]'
    type: int
    value: '2'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab_widget_0@1:2,0,1,1
    label: Sweeping method
    label0: Sweep carrier frequency
    label1: Sweep generated frequency
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: vector_data
  id: variable
  parameters:
    value: range(vector_length)
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: x_start
  id: variable
  parameters:
    value: '86'
  states: {}
- name: x_step
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: vector_data
    vlen: vector_length
  states: {}
- name: epy_module_client
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import socket
      from gnuradio import eng_notation
      from PyQt5 import Qt

      def client(tt):
          # Storage variables initial values
          variables=["entry_var_frequency_","var_waveform_","entry_var_amplitude_","entry_var_offset_","entry_var_sample_rate_gr","entry_var_sample_rate_osmosdr","entry_var_carrying_frequency","entry_var_measured_frequency","entry_start_freq","entry_span_freq","entry_end_freq"]
          old_values=[]
          for variable in variables:
              exec("old_values.append(tt.get_{}())".format(variable))
              # Convert default values of entry controls to eng notation 
              if("entry" in variable):
                  Qt.QMetaObject.invokeMethod(eval("tt._{}_line_edit".format(variable)), "setText", Qt.Q_ARG("QString", eng_notation.num_to_str(eval("tt.{}".format(variable)))))
          while True:
              # Try to connect
              host = '192.168.137.8'
              port = 4242
              client_socket = socket.socket()
              try:
                  client_socket.connect((host, port))
              except:
                  pass
              if(client_socket.getsockname()[0] != "0.0.0.0"):
                  # Connected
                  print("Connected to server")
                  while True:
                      # Check if variables have changed to send the new values
                      for i, variable in enumerate(variables):
                          if((eval("tt.get_{}()".format(variable))!=old_values[i]) & ("var" in variable)):
                              value=eval("tt.get_{}()".format(variable))
                              if(variable=="var_waveform_"):
                                  value=value+100

                              message=variable + "=" + str(value) + ">" # Encoding message to send it
                              client_socket.send(message.encode())
                              # Register updated variable value
                              old_values[i]=eval("tt.get_{}()".format(variable))                    
                          # Check if "entry" controls text has been modified to change its color (indicating pending "enter" key)
                          if "entry" in variable:
                              try: # To catch when incorrect value is typed
                                  if(eval("eng_notation.str_to_num(str(tt._{var_name}_line_edit.text()))!=float(tt.get_{var_name}())".format(var_name=variable))):
                                      if(eval("tt._{}_tool_bar.styleSheet()".format(variable))!="QLabel {background-color: yellow}"):
                                          Qt.QMetaObject.invokeMethod(eval("tt._{}_tool_bar".format(variable)), "setStyleSheet", Qt.Q_ARG("QString", "QLabel {background-color: yellow}"))
                                  else:
                                      if(eval("tt._{}_tool_bar.styleSheet()".format(variable))!=""):
                                          Qt.QMetaObject.invokeMethod(eval("tt._{}_tool_bar".format(variable)), "setStyleSheet", Qt.Q_ARG("QString", ""))                        
                              except:
                                  if(eval("tt._{}_tool_bar.styleSheet()".format(variable))!="QLabel {background-color: red}"):
                                          Qt.QMetaObject.invokeMethod(eval("tt._{}_tool_bar".format(variable)), "setStyleSheet", Qt.Q_ARG("QString", "QLabel {background-color: red}"))
                                  pass
                          # Check if "start" has been pressed
                          btn_index=5
                          if((tt.get_btn_start()==1) & (tt.tab_widget_0_grid_layout_1.itemAt(btn_index).widget().text() == "Start")):
                              tt.tab_widget_0_grid_layout_1.itemAt(btn_index).widget().setText("Stop")
                              tt.set_btn_start(0)
                              tt.set_sweeping("True")
                          elif((tt.get_btn_start()==1) & (tt.tab_widget_0_grid_layout_1.itemAt(btn_index).widget().text() == "Stop")):
                              tt.tab_widget_0_grid_layout_1.itemAt(btn_index).widget().setText("Start")
                              tt.set_btn_start(0)
                              tt.set_sweeping("False")
                      # client_socket.close()
  states: {}
- name: epy_module_sweep
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nimport numpy as np\nimport zmq\nimport array\nfrom PyQt5 import Qt\nimport time\nimport scipy.interpolate as interp\n\n# Function to divide the frequencies sub-lists\ndef list_split(listA, n):\n    for x in range(0, len(listA), n):\n        every_chunk = listA[x: n+x]\n        yield every_chunk\n#\ndef sweep(tt):\n    Nt=10\n    context=zmq.Context()\n    \n    mean_amplitude=[]\n    mean_amplitude_array=[]\n    # mean_amplitude_array=np.array([0])\n    while True:\n        while tt.get_sweeping()==\"True\":\n            # Retrieve start, span and end frequency\n            start_freq=tt.get_entry_start_freq()/5\n            span_freq=tt.get_entry_span_freq()\n            end_freq=tt.get_entry_end_freq()/5\n            # Calculate the frequency range\n            frequencies=np.arange(start_freq,end_freq,span_freq).tolist()\n            frequencies.append(end_freq)\n            n=int(len(frequencies)/((end_freq-start_freq)/100e3))\n            frequency_chunks=list(list_split(frequencies, n))\n            # Main procees\n            for set in frequency_chunks:\n                print(\"Changing carry frequency: {}\".format(float(set[0])))\n                # tt.set_entry_var_carrying_frequency(float(set[0]))\n                for f in set:\n                    # tt.set_entry_var_frequency_(float(f))\n                    tt.set_entry_var_carrying_frequency(float(f)) \n                    time.sleep(0.75) # Sleep for 500 miliseconds\n                    if tt.get_sweeping()==\"False\":\n                        break\n                    # Record stream of data\n                    sock1=context.socket(zmq.SUB)\n                    sock1.connect(\"tcp://192.168.137.8:5555\")\n                    sock1.setsockopt(zmq.SUBSCRIBE,b\"\")\n                    raw_recv=sock1.recv()\n                    sock1.close()\n                    recv=array.array('f',raw_recv) #float\n                    recv=recv[1::2]\n                    # mean_amplitude.append(np.mean(np.abs(recv)))      # Absolute values\n                    a = np.array( [ num for num in recv if num >= 0 ] ) # Only positive values\n                    mean_amplitude.append(np.mean(a)) # \n                    mean_amplitude_array=np.array(mean_amplitude)\n                    try:\n                        # Plot the results\n                        arr_ref = np.array(range(int(tt.get_vector_length()))) # Reference array for inporlation\n                        mean_interp = interp.interp1d(np.arange(mean_amplitude_array.size),mean_amplitude_array)\n                        new_mean_amplitude_array = mean_interp(np.linspace(0,mean_amplitude_array.size-1,arr_ref.size))\n                        tt.set_vector_data(new_mean_amplitude_array)\n                    except:\n                        pass\n            tt.set_x_start((frequencies[0]*5)/1e6)\n            tt.set_x_step(((frequencies[len(frequencies)-1]-frequencies[0])/tt.get_vector_length())/1e6)\n            # All frequencies tested, set button back to \"Start\"\n            btn_index=5\n            tt.tab_widget_0_grid_layout_1.itemAt(btn_index).widget().setText(\"Start\")\n            tt.set_sweeping(\"False\")\n            # Reset arrays\n            mean_amplitude=[]\n            mean_amplitude_array=[]\n\n"
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    comment: tab_widget_0@0:1,0,1,4
    fc: entry_var_measured_frequency
    fftsize: '4096'
    grid: 'True'
    gui_hint: tab_widget_0@0:1,0,1,4
    tr_level: '-14'
    type: complex
    wintype: firdes.WIN_HAMMING
    ymax: '-5'
    ymin: '-90'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,4
    size: '1024'
    srate: sample_rate
    tr_level: '0.4'
    type: complex
    ymax: '1.1'
    ymin: '-1.1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: tab_widget_0@1
    grid: 'True'
    gui_hint: tab_widget_0@1:0,0,1,4
    vlen: vector_length
    x_axis_label: '"Frequency (MHz)"'
    x_start: x_start
    x_step: x_step
    x_units: '"MHz"'
    y_axis_label: '"Relative Mean voltage"'
    y_units: '"dB"'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting client and GUI")
      import threading
      threading.Thread(target=epy_module_client.client, daemon=True, args=(self,)).start()
      threading.Thread(target=epy_module_sweep.sweep, daemon=True, args=(self,)).start()
    section: main_after_init
  states: {}
- name: tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: Noise source
    label1: Frequency sweep
    num_tabs: '2'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
