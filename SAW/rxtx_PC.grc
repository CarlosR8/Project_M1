options:
  parameters:
    author: cmrivera
    generate_options: qt_gui
    id: rxtx_PC
    output_language: python
    title: GNU Spectrum Analyzer by Carlos RIVERA
  states: {}

blocks:
- name: amplitude_
  id: variable_qtgui_entry
  parameters:
    comment: 5,0,1,2
    gui_hint: 5,0,1,2
    label: 'Amplitude                   '
    type: real
    value: '300e-3'
  states: {}
- name: btn_start
  id: variable_qtgui_push_button
  parameters:
    comment: tab_widget_0@1:1,3,1,1
    gui_hint: tab_widget_0@1:1,3,1,1
    label: '"Start"'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: carrying_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 6,0,1,2
    gui_hint: 6,0,1,2
    label: 'Carrying frequency     '
    type: real
    value: 86.8e6
  states: {}
- name: end_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,3,1,1
    gui_hint: tab_widget_0@1:1,2,1,1
    label: End frequency
    type: real
    value: '0.5'
  states: {}
- name: frequency_
  id: variable_qtgui_entry
  parameters:
    comment: 4,0,1,2
    gui_hint: 4,0,1,2
    label: 'Test frequency           '
    type: real
    value: 10e3
  states: {}
- name: measured_frequency
  id: variable_qtgui_entry
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    label: 'Measured Frequency  '
    type: real
    value: 434e6
  states: {}
- name: offset_
  id: variable_qtgui_entry
  parameters:
    comment: 5,2,1,2
    gui_hint: 5,2,1,2
    label: 'Offset                        '
    type: real
    value: '0.5'
  states: {}
- name: record
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    comment: sample_rate = sample_rate_osmosdr
    value: sample_rate_osmosdr
  states: {}
- name: sample_rate_gr
  id: variable_qtgui_entry
  parameters:
    comment: 6,2,1,2
    gui_hint: 6,2,1,2
    label: 'Sample rate gr-rpitx  '
    type: real
    value: 200e3
  states: {}
- name: sample_rate_osmosdr
  id: variable_qtgui_entry
  parameters:
    comment: 7,2,1,2
    gui_hint: 7,2,1,2
    label: Sample rate Osmosdr
    type: real
    value: 1.152e6
  states: {}
- name: span_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,2,1,1
    gui_hint: tab_widget_0@1:1,1,1,1
    label: Span
    type: real
    value: '0.5'
  states: {}
- name: start_freq
  id: variable_qtgui_entry
  parameters:
    comment: tab_widget_0@1:1,0,1,1
    gui_hint: tab_widget_0@1:1,0,1,1
    label: Start frequency
    type: real
    value: '300e-3'
  states: {}
- name: vector_data
  id: variable
  parameters:
    value: range(512)
  states: {}
- name: waveform_
  id: variable_qtgui_chooser
  parameters:
    comment: 4,2,1,2
    gui_hint: 4,2,1,2
    label: 'Waveform                  '
    labels: '["Constant","Sine","Cosine","Square","Triangle","Saw Tooth"]'
    num_opts: '0'
    options: '[0,1,2,3,4,5]'
    type: int
    value: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: vector_data
    vlen: '512'
  states: {}
- name: epy_module_client
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import socket
      from gnuradio import eng_notation
      from PyQt5 import Qt

      def client(tt):
          # Storage variables initial values
          variables=["frequency_","waveform_","amplitude_","offset_","sample_rate_gr","sample_rate_osmosdr","carrying_frequency","measured_frequency"]
          old_values=[]
          for variable in variables:
              exec("old_values.append(tt.get_{}())".format(variable))
              # Convert default values of entry controls to eng notation 
              if(variable == "waveform_"):
                  continue # Skip if not an entry control
              Qt.QMetaObject.invokeMethod(eval("tt._{}_line_edit".format(variable)), "setText", Qt.Q_ARG("QString", eng_notation.num_to_str(eval("tt.{}".format(variable)))))
          while True:
              # Try to connect
              host = '192.168.137.8'
              port = 4242
              client_socket = socket.socket()
              try:
                  client_socket.connect((host, port))
              except:
                  pass
              if(client_socket.getsockname()[0] != "0.0.0.0"):
                  # Connected
                  print("Connected to server")
                  while True:
                      # Check if variables have changed to send the new values
                      for i, variable in enumerate(variables):
                          if(eval("tt.get_{}()".format(variable))!=old_values[i]):
                              value=eval("tt.get_{}()".format(variable))
                              if(variable=="waveform_"):
                                  value=value+100

                              message=variable + "=" + str(value) + ">" # Encoding message to send it
                              client_socket.send(message.encode())
                              # Register updated variable value
                              old_values[i]=eval("tt.get_{}()".format(variable))
                              # testing
                              # tt._frequency__tool_bar.setStyleSheet("QLabel { }")
                              
                          # Check if "entry" controls text has been modified to change its color (indicating pending "enter" key)
                          try: # To ignore when incorrect value is typed
                              if(variable=="waveform_"): # If the current variable is not an "entry" ignore
                                  pass

                              if(eval("eng_notation.str_to_num(str(tt._{var_name}_line_edit.text()))!=float(tt.get_{var_name}())".format(var_name=variable))):
                                  if(eval("tt._{}_tool_bar.styleSheet()".format(variable))!="QLabel {background-color: yellow}"):
                                      Qt.QMetaObject.invokeMethod(eval("tt._{}_tool_bar".format(variable)), "setStyleSheet", Qt.Q_ARG("QString", "QLabel {background-color: yellow}"))
                              else:
                                  if(eval("tt._{}_tool_bar.styleSheet()".format(variable))!=""):
                                      Qt.QMetaObject.invokeMethod(eval("tt._{}_tool_bar".format(variable)), "setStyleSheet", Qt.Q_ARG("QString", ""))                        
                          except:
                              pass
                          
                      # client_socket.close()
  states: {}
- name: epy_module_sweep
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph

      import numpy as np
      import zmq
      import array
      from PyQt5 import Qt

      def sweep(tt):
          while True:
              # Check if "start" has been pressed
              if((tt.get_btn_start()==1) & (tt.tab_widget_0_grid_layout_1.itemAt(4).widget().text() == "Start")):
                  tt.tab_widget_0_grid_layout_1.itemAt(4).widget().setText("Stop")
                  tt.set_btn_start(0)
              elif((tt.get_btn_start()==1) & (tt.tab_widget_0_grid_layout_1.itemAt(4).widget().text() == "Stop")):
                  tt.tab_widget_0_grid_layout_1.itemAt(4).widget().setText("Start")
                  tt.set_btn_start(0)
              # Retrieve start, span and end frequency
              # start_freq=tt.get_start_freq()
              # span_freq=tt.get_span_freq()
              # stop_freq=tt.get_end_freq()
              # pass
              # Nt=10
              # context=zmq.Context()
              # sock1=context.socket(zmq.SUB)
              # sock1.connect("tcp://192.168.137.8:5555");
              # sock1.setsockopt(zmq.SUBSCRIBE,b"")
              # vector1=[]
              # print("start")
              # while(len(vector1)<Nt):
              #     raw_recv=sock1.recv()
              #     recv=array.array('f',raw_recv) #float
              #     # recv=array.array('l',raw_recv) #integer
              #     # print(recv)
              #     vector1.append(recv)

              # print("finish")
              # # print(recv)
              # f = open("data.txt", "w")
              # f.write(str(recv))
              # f.close()
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: sample_rate
    comment: tab_widget_0@0:1,0,1,4
    fc: measured_frequency
    fftsize: '4096'
    grid: 'True'
    gui_hint: tab_widget_0@0:1,0,1,4
    tr_level: '-14'
    type: complex
    wintype: firdes.WIN_HAMMING
    ymax: '-5'
    ymin: '-77'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,4
    size: '1024'
    srate: sample_rate
    tr_level: '0.4'
    type: complex
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: tab_widget_0@1
    gui_hint: tab_widget_0@1:0,0,1,4
    vlen: '512'
    x_axis_label: '"Frequency (Hz)"'
    x_start: '0'
    x_step: '1.0'
    x_units: '"Hz"'
    y_axis_label: '"Relative Gain (dB)"'
    y_units: '"dB"'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting client and GUI")
      import threading
      threading.Thread(target=epy_module_client.client, daemon=True, args=(self,)).start()
      threading.Thread(target=epy_module_sweep.sweep, daemon=True, args=(self,)).start()
    section: main_after_init
  states: {}
- name: tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: Noise source
    label1: Frequency sweep
    num_tabs: '2'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', qtgui_vector_sink_f_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
