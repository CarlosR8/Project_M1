options:
  parameters:
    author: cmrivera
    generate_options: no_gui
    id: rx_Pi
    output_language: python
    title: Raspberry Pi Receiver
  states: {}

blocks:
- name: measured_frequency
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: sample_rate_osmosdr
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: epy_module_shared_variable
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph

      import json  # To save variables as json
      import os.path
      from os import path
      # Declaring class for "shared variable" object (communication between flowcharts)
      class Shared_Variable:
      	names = [] # List of variable names
      	values = [] # List of variable values
      	shared_variables = [] # List of variables set on init
      	def __init__(self,shared_variables_):
      		self.shared_variables = shared_variables_
      		pass
      	def clear(self):
      		self.names = []
      		self.values = []
      	def save_variables(self, tt):
      		# try:
      			self.clear()
      			for variable in self.shared_variables:
      				self.names.append(variable)
      				self.values.append(eval("tt.get_{}()".format(variable)))
      			# Saving in json file
      			f = open("shared_variables.json", "w")
      			f.write(json.dumps(self.__dict__))
      			f.close()
      		# except:
      		# 	pass
      	def retrieve_variables(self, tt):
      		# Check if file exist
      		if(path.exists("shared_variables.json")):
      			with open("shared_variables.json") as f:
      				content = f.readline()
      				self.__dict__ = json.loads(content)
      			# Once read, remove it	
      			os.remove("shared_variables.json")	
      		
      # 

      def main(tt):
          while True:
              pass
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: measured_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate_osmosdr
    sync: sync
    type: fc32
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting Receiver")
      import threading
      threading.Thread(target=epy_module_shared_variable.main,args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
