options:
  parameters:
    author: cmrivera
    generate_options: no_gui
    id: rx_Pi
    output_language: python
    title: Raspberry Pi Receiver
  states: {}

blocks:
- name: amplitude_
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: carrying_frequency
  id: variable
  parameters:
    value: 86.8e6
  states: {}
- name: frequency_
  id: variable
  parameters:
    value: 86.8e6
  states: {}
- name: measured_frequency
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: offset_
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: sample_rate_gr
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sample_rate_osmosdr
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: waveform_
  id: variable
  parameters:
    comment: |-
      Constant = 100
      Sine = 101
      Cosine = 102
      Square = 103
      Triangle = 104
      Saw Tooth = 105
    value: '103'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude_
    freq: frequency_
    offset: offset_
    phase: '0'
    samp_rate: sample_rate_gr
    type: float
    waveform: waveform_
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: epy_module_server
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      import socket
      # import string

      def server(tt):
      	while True:
      		# Configure socket
      		sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)
      		sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
      		sock.bind(('192.168.137.8',4242))
      		# Listen
      		print("Waiting for connection...")
      		sock.listen(1)
      		# Connected
      		conn,addr=sock.accept()
      		with conn:
      			print('Connected from: ', addr)
      			message = "" # Variable to store complete message
      			while True:
      				# Get text
      				data=conn.recv(1)
      				if data:
      					data=data.decode()
      					message = message+data
      					# print(message)
      					if '>' in message: # Delimeter to indicate end of message
      						try:
      							# Changing variables
      							message = message.replace('>','').strip()
      							[var_name, var_value] = message.split("=")
      							command = "tt.set_{}(float({}))".format(var_name, var_value)
      							exec(command) 
      							print("The new value of the variable {} is: {}".format(var_name, var_value))
      							message = "" # Reset variable
      						except:
      							message = "" # Reset variable
      							print("Error: variable not set")						
      					# Quit
      					if 'quit' in data:
      						print("Closing connection...")
      						sock.shutdown(socket.SHUT_RDWR)
      						sock.close()
      						break # Back to listen loop
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: measured_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate_osmosdr
    sync: sync
    type: fc32
  states: {}
- name: rpitx_rpitx_sink_0
  id: rpitx_rpitx_sink
  parameters:
    carrier_freq: carrying_frequency
    samp_rate: sample_rate_gr
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server")
      import threading
      threading.Thread(target=epy_module_server.server,args=(self,)).start()
    section: main_after_init
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://192.168.137.8:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_magphase_to_complex_0, '0', rpitx_rpitx_sink_0, '0']
- [osmosdr_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
