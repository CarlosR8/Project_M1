options:
  parameters:
    author: cmrivera
    generate_options: no_gui
    id: tx_Pi
    output_language: python
    title: Raspberry pi emitter (gr-rpitx)
  states: {}

blocks:
- name: entry_var_amplitude_
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: entry_var_carrying_frequency
  id: variable
  parameters:
    value: 86.8e6
  states: {}
- name: entry_var_frequency_
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: entry_var_measured_frequency
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: entry_var_offset_
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: entry_var_sample_rate_gr
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: entry_var_sample_rate_osmosdr
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: var_waveform_
  id: variable
  parameters:
    comment: |-
      Constant = 100
      Sine = 101
      Cosine = 102
      Square = 103
      Triangle = 104
      Saw Tooth = 105
    value: '101'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: entry_var_amplitude_
    freq: entry_var_frequency_
    offset: entry_var_offset_
    phase: '0'
    samp_rate: entry_var_sample_rate_gr
    type: float
    waveform: var_waveform_
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: epy_module_server
  id: epy_module
  parameters:
    source_code: |-
      # this module will be imported in the into your flowgraph
      import socket
      # import string
      import json  # To save variables as json
      import ntpath  # To retrieve file name out of address
      import os.path
      from os import path

      # Declaring class for "shared variable" object (communication between flowcharts)
      class Shared_Variable:
      	names = [] # List of variable names
      	values = [] # List of variable values
      	shared_variables = [] # List of variables set on init
      	def __init__(self,shared_variables_):
      		self.shared_variables = shared_variables_
      		pass
      	def clear(self):
      		self.names = []
      		self.values = []
      	def save_variables(self, tt):
      		# try:
      			self.clear()
      			for variable in self.shared_variables:
      				self.names.append(variable)
      				self.values.append(eval("tt.get_{}()".format(variable)))
      			# Saving in json file
      			f = open("shared_variables.json", "w")
      			f.write(json.dumps(self.__dict__))
      			f.close()
      		# except:
      		# 	pass
      	def retrieve_variables(self, tt):
      		# Check if file exist
      		if(path.exists("shared_variables.json")):
      			with open("shared_variables.json") as f:
      				content = f.readline()
      				self.__dict__ = json.loads(content)
      			# Once read, remove it	
      			os.remove("shared_variables.json")	
      		
      # 

      def server(tt):
      	while True:
      		# Create list of shared variables
      		shared_variables = ["entry_var_sample_rate_osmosdr","entry_var_measured_frequency"]
      		sFile = Shared_Variable(shared_variables)
      		#Save current local variables to share them
      		sFile.save_variables(tt)

      		# Configure socket
      		sock=socket.socket(socket.AF_INET, socket.SOCK_STREAM)
      		sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
      		sock.bind(('192.168.137.8',4242))
      		# Listen
      		print("Waiting for connection...")
      		sock.listen(1)
      		# Connected
      		conn,addr=sock.accept()
      		with conn:
      			print('Connected from: ', addr)
      			message = "" # Variable to store complete message
      			while True:
      				# Get text
      				data=conn.recv(1)
      				if data:
      					data=data.decode()
      					message = message+data
      					# print(message)
      					if '>' in message: # Delimeter to indicate end of message
      						try:
      							# Changing local variables
      							message = message.replace('>','').strip()
      							[var_name, var_value] = message.split("=")
      							command = "tt.{}=float({})".format(var_name, var_value)
      							exec(command) 
      							command = "tt.set_{}(float({}))".format(var_name, var_value)
      							exec(command) 
      							print("The new value of the variable {} is: {}".format(var_name, var_value))
      							message = "" # Reset message variable

      							# Save current values on "shared variables" file
      							sFile.save_variables(tt)
      						except:
      							message = "" # Reset message variable
      							print("Error: variable not set")						
      					# Quit
      					if 'quit' in data:
      						print("Closing connection...")
      						sock.shutdown(socket.SHUT_RDWR)
      						sock.close()
      						break # Back to listen loop
      			# C
  states: {}
- name: rpitx_rpitx_sink_0
  id: rpitx_rpitx_sink
  parameters:
    carrier_freq: entry_var_carrying_frequency
    samp_rate: entry_var_sample_rate_gr
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print("Starting server")
      import threading
      threading.Thread(target=epy_module_server.server,args=(self,)).start()
      from subprocess import Popen
      Popen(['python', 'rx_Pi.py'])
    section: main_after_init
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_magphase_to_complex_0, '0', rpitx_rpitx_sink_0, '0']

metadata:
  file_format: 1
